# Keil uVision project stm32f4_demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f4_demo
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source Group 1
    ./: startup_stm32f10x_ld.s main.c
